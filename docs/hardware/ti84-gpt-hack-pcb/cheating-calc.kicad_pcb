# Repository rgomez31UAQ/TI84-ESP32-GEMINI

File README.md:

# TI84-ESP32-GEMINI

Proyecto unificado para usar una TI-84 + ESP32 con backend de IA multi-proveedor (Gemini como base y fallback opcional).

Base tomada de:

- `TI-GPT` (estructura PlatformIO + Gemini inicial)
- `TI-84-GPT-HACK` (protocolo TI robusto, funciones extra, servidor y ruta de camara)

Referencias:

- <https://github.com/ExodowRRGB/TI-GPT>
- <https://github.com/ChinesePrince07/TI-84-GPT-HACK>
- <https://www.andypandy.org/projects/ti-84-gpt-hack/>
- <https://andisearch.com/>

## Codigo exportado por origen

De `TI-84-GPT-HACK` se exporto y adapto:

- `esp32/esp32.ino` -> `firmware/src/main.ino`
- `esp32/*.h` -> `firmware/include/*.h`
- `server/routes/*`, `server/index.mjs`, `server/firmware`, `server/images`, `server/programs`, `server/version.txt`

De `TI-GPT` se tomo la idea de compilacion en PlatformIO y llamada a Gemini para dejar esta version integrada.

## Mejor opcion practica

1. Backend en nube (URL HTTPS publica y estable).
1. ESP32 con portal AP para configurar WiFi/hotspot desde telefono.
1. Cadena de IA con fallback: `gemini -> groq -> openrouter`.

Este enfoque evita depender de una laptop encendida 24/7 y mantiene el proyecto open-source y de bajo costo.

## Estructura

- `firmware/`: proyecto PlatformIO para el ESP32
- `server/`: backend Node.js con rutas compatibles (`/gpt`, `/programs`, `/image`, `/firmware`, `/logs`)
- `render.yaml`: blueprint para desplegar rapido en Render

## Firmware (ESP32)

1. Ve a `firmware/platformio.ini` y ajusta tu placa si hace falta.
1. Perfil por defecto actual: `xiao_esp32s3_local` (Seeed XIAO ESP32S3).
1. El archivo incluye 4 perfiles:
1. `xiao_esp32c3_local` (backend local)
1. `xiao_esp32c3_cloud` (backend cloud con HTTPS)
1. `xiao_esp32s3_local` (backend local)
1. `xiao_esp32s3_cloud` (backend cloud con HTTPS)
1. Compila y sube (ejemplo cloud):

```bash
cd firmware
pio run -e xiao_esp32c3_cloud -t upload
```

Para local:

```bash
cd firmware
pio run -e xiao_esp32c3_local -t upload
```

Para XIAO ESP32S3 (recomendado en este repo):

```bash
cd firmware
pio run -e xiao_esp32s3_local -t upload
```

Para pruebas de camara (OCR + solve por imagen):

```bash
cd firmware
pio run -e xiao_esp32s3_camera_local -t upload
```

## Pruebas por terminal (sin calculadora)

Si aun no conectas la TI-84, puedes validar ESP32 <-> backend desde serie.

1. Abre monitor serie:

```bash
cd firmware
pio device monitor -b 115200 --port /dev/ttyACM1
```

1. Comandos CLI disponibles en el ESP32:
1. `HELP`
1. `STATUS`
1. `AP`
1. `WIFI <ssid> <password>`
1. `SERVER <url>` (ejemplo `SERVER http://192.168.1.50:8080`)
1. `HEALTH`
1. `ASK hola desde terminal`
1. `CAMSTATUS`
1. `CAMOCR 1`
1. `CAMSOLVE 1`

Flujo recomendado:

1. `WIFI <ssid> <password>`
1. `SERVER http://<IP_RASPBERRY>:8080`
1. `HEALTH` (debe responder JSON con `"ok":true`)
1. `ASK prueba desde esp32`

Nota: si no hay credenciales guardadas o falla la conexion, el firmware levanta automaticamente el AP `calc`.

## Integracion ESP32 + TI-84 (pruebas en pantalla)

Esta seccion esta enfocada en conectar fisicamente la calculadora para validar respuestas directamente en pantalla TI-84.

### Pinout usado en este firmware

En este repo, el firmware define los pines de enlace en `firmware/src/main.ino`:

- `TIP = D1`
- `RING = D10`
- `SLEEVE = GND`

Mapa de conexion al jack 2.5mm TRS de la TI-84:

| TI-84 link jack | ESP32 (este repo) | Nota |
| --- | --- | --- |
| Tip | `D1` | Linea de datos TI link |
| Ring | `D10` | Linea de datos TI link |
| Sleeve | `GND` | Tierra comun |

Si no hay comunicacion, intercambia Tip y Ring.

### Esquema rapido de cableado

```text
TI-84 2.5mm TRS jack             ESP32 (XIAO)
----------------------           -----------------
TIP   -------------------------> D1
RING  -------------------------> D10
SLEEVE-------------------------> GND
```

### Diagrama visual (pinout)

### Pasos de conexion recomendados

1. Usa un conector TRS 2.5mm (el de la TI-84) con tres conductores.
1. Conecta `SLEEVE` primero a `GND` del ESP32.
1. Conecta `TIP` y `RING` a `D1` y `D10` respectivamente.
1. Flashea firmware y prueba con la calculadora.
1. Si falla la deteccion de enlace, intercambia `TIP` y `RING`.

### Referencia de pines de otros proyectos

En `TI-GPT`, el ejemplo de cableado usa `GPIO22` y `GPIO23`.

En este repositorio integrado se usa `D1`/`D10` por compatibilidad con la configuracion actual de `main.ino`.

## Esquemas e imagenes de PCB (importadas)

Se importo el diseno de referencia desde `TI-84-GPT-HACK/pcb` a:

- `docs/hardware/ti84-gpt-hack-pcb/schematic.png`
- `docs/hardware/ti84-gpt-hack-pcb/built.png`
- `docs/hardware/ti84-gpt-hack-pcb/outline.svg`
- `docs/hardware/ti84-gpt-hack-pcb/cheating-calc.kicad_pcb`
- `docs/hardware/ti84-gpt-hack-pcb/cheating-calc.kicad_sch`

Vista de esquematico:

Vista de PCB ensamblada:

Para abrir y editar el diseno de PCB, usa KiCad con:

- `docs/hardware/ti84-gpt-hack-pcb/cheating-calc.kicad_sch`
- `docs/hardware/ti84-gpt-hack-pcb/cheating-calc.kicad_pcb`

## BOM minimo (armado)

### Opcion A: cableado directo (sin PCB)

| Cantidad | Componente | Nota |
| --- | --- | --- |
| 1 | Seeed XIAO ESP32S3 | Recomendado en este repo |
| 1 | Conector 2.5mm TRS macho o cable TI link cortado | Para TIP/RING/SLEEVE |
| 3 | Cables jumper o cable siliconado | TIP, RING y GND |
| 1 | Fuente USB 5V (o bateria USB) | Alimentacion del ESP32 |

Conexion directa:

- `TIP -> D1`
- `RING -> D10`
- `SLEEVE -> GND`

### Opcion B: PCB de referencia importada (TI-84-GPT-HACK)

| Ref | Cantidad | Componente (schematic importado) | Archivo fuente |
| --- | --- | --- | --- |
| U1 | 1 | `MOUDLE-SEEEDUINO-XIAO-ESP32C3` | `docs/hardware/ti84-gpt-hack-pcb/cheating-calc.kicad_sch` |
| Q1, Q2 | 2 | `MMBF170` | `docs/hardware/ti84-gpt-hack-pcb/cheating-calc.kicad_sch` |
| R1, R2, R3, R4 | 4 | `R` (valor no especificado en el schematic importado) | `docs/hardware/ti84-gpt-hack-pcb/cheating-calc.kicad_sch` |
| J1 | 1 | `Conn_01x04` | `docs/hardware/ti84-gpt-hack-pcb/cheating-calc.kicad_sch` |

Notas importantes:

- La PCB importada es una referencia de hardware del proyecto `TI-84-GPT-HACK`.
- El firmware de este repo esta ajustado para `XIAO ESP32S3` y pines `D1/D10`.
- Si fabricas PCB, verifica pin mapping y valores de resistencias antes de mandar a produccion.

## Servidor (Multi-IA)

1. Instala dependencias:

```bash
cd server
npm install
```

1. Crea `.env` desde `.env.example` y pon tu key de Google AI Studio.

1. Opcional: agrega keys de fallback (Groq/OpenRouter) para no caerte por cuota de un solo proveedor.

1. Inicia el servidor:

```bash
npm start
```

El firmware consulta estas rutas:

- `GET /gpt/ask`
- `GET /gpt/history`
- `POST /gpt/ocr` (extraer texto OCR desde imagen)
- `POST /gpt/solve` (OCR -> texto -> solucion con IA)

### Variables clave de `.env`

- `AI_PROVIDER_ORDER=openai,groq,openrouter,gemini`
- `GOOGLE_API_KEY=...`
- `GROQ_API_KEY=...` (opcional)
- `OPENROUTER_API_KEY=...` (opcional)
- `OPENAI_API_KEY=...` (opcional, ChatGPT)
- `VISION_PROVIDER_ORDER=openai,openrouter,gemini`
- `OCR_PROVIDER_ORDER=openai,openrouter,gemini`
- `OPENROUTER_VISION_MODEL=openrouter/free` (fallback de vision)

## Despliegue en nube

### Opcion recomendada para empezar (gratis/freemium): Render

1. Sube este proyecto a GitHub.
1. En Render, usa `New + -> Blueprint` y selecciona este repo (usa `render.yaml`).
1. Si no usas Blueprint, crea `Web Service` manual con:
1. Root Directory: `server`
1. Build Command: `npm install`
1. Start Command: `npm start`
1. Health Check Path: `/healthz`
1. Variables de entorno: copia las de `.env.example`.
1. Despliega y copia la URL HTTPS publica.

Si ya tienes cuenta Render con GitHub conectada, este flujo suele tardar solo unos minutos.

Luego, en `firmware/platformio.ini`, define por ejemplo:

```ini
build_flags = -D SERVER=\"https://tu-app.onrender.com\" -D SECURE
```

### Otras nubes gratuitas o freemium recomendadas

1. Render: muy facil para Node.js, plan gratis con sleep por inactividad.
1. Railway: simple de usar, normalmente con creditos gratis temporales.
1. Koyeb: tiene plan free para servicios pequenos.
1. Fly.io: muy bueno tecnicamente, pero puede requerir tarjeta o costos minimos segun region/uso.

### Railway (alternativa rapida)

1. Sube el repo a GitHub.
1. En Railway, crea `New Project -> Deploy from GitHub Repo`.
1. Selecciona carpeta `server` como root de servicio si Railway lo solicita.
1. Railway puede usar `server/railway.json` automaticamente.
1. Agrega variables de entorno de `.env.example`.

### Docker (portabilidad)

`server/Dockerfile` y `server/.dockerignore` estan incluidos para despliegue en cualquier proveedor con contenedores.

## Opcion sin tarjeta: Raspberry Pi Zero 2 W

Si Render te pide tarjeta, puedes correr el backend en una Raspberry Pi Zero 2 W.

Resumen rapido:

1. Instala `Raspberry Pi OS Lite 64-bit`.
1. En la Pi, ejecuta:

```bash
git clone https://github.com/rgomez31UAQ/TI84-ESP32-GEMINI.git
cd TI84-ESP32-GEMINI
sudo bash scripts/pi/setup_pi_backend.sh
```

1. Edita `/etc/ti84-backend.env` con tus keys.
1. Verifica backend:

```bash
curl -sS http://127.0.0.1:8080/healthz
```

1. En el portal AP `calc` del ESP32, pon `Backend URL` a:
1. `http://ti84pi.local:8080` o la IP local de la Pi.

Guia completa:

- `docs/RPI_ZERO2W_SETUP.md`

Scripts incluidos:

- `scripts/pi/setup_pi_backend.sh`
- `scripts/pi/update_pi_backend.sh`
- `scripts/pi/install_tailscale.sh`
- `scripts/pi/configure_pi_wifi.sh`
- `scripts/pi/ti84-backend.service`

Para mantener la Raspberry conectada al cambiar entre modem y hotspot:

```bash
cd /opt/TI84-ESP32-GEMINI
sudo bash scripts/pi/configure_pi_wifi.sh add "MiModemCasa" "clave_modem" 90
sudo bash scripts/pi/configure_pi_wifi.sh add "MiHotspot" "clave_hotspot" 70
```

Usa `http://ti84pi.local:8080` como Backend URL para evitar depender de IP fija.

## Publicar en GitHub (manual)

Repositorio remoto configurado:

- `origin = https://github.com/rgomez31UAQ/TI84-ESP32-GEMINI.git`

Si el repo aun no existe, crealo en GitHub con ese nombre y luego ejecuta:

```bash
cd TI84-ESP32-GEMINI
git push -u origin main
```

Si Git pide autenticacion por HTTPS, usa un token personal (PAT) con permisos de `repo`.

## Red para el ESP32

1. El ESP32 puede crear AP (`calc`) para configuracion inicial.
1. Desde ese portal puedes conectarlo a WiFi normal o hotspot de telefono.
1. El portal incluye boton `Scan Nearby WiFi` para listar SSIDs cercanos y autocompletar el nombre de red.
1. Desde ese mismo portal puedes definir la URL del backend (Render/Railway) sin recompilar firmware.
1. Para Raspberry local, usa `http://ti84pi.local:8080` como URL estable aun cuando cambie la IP.
1. Para movilidad, hotspot del telefono es la opcion mas practica.
1. Para uso continuo, WiFi fijo + backend en nube es la opcion mas estable.

### Seguridad recomendada

1. No guardes API keys de IA en el ESP32: deben quedarse solo en el backend de nube.
1. En el portal AP configura solo `WiFi` y `Backend URL`.
1. Rota tus keys (GitHub/Gemini/Groq/OpenRouter) si las compartes en texto plano.

## Siguiente paso operativo

1. Desplegar backend en Render o Railway y obtener URL publica HTTPS.
1. Ajustar `firmware/platformio.ini` con:

```ini
build_flags = -D SERVER=\"https://TU-URL-PUBLICA\" -D SECURE
```

1. Compilar/subir firmware y configurar WiFi del ESP32 desde el portal AP `calc`.
1. Verificar backend en `https://TU-URL-PUBLICA/healthz` antes de probar desde la calculadora.

## Notas

- El endpoint de firmware es compatible con el protocolo de `TI-84-GPT-HACK`.
- Para respuestas en pantalla TI-84, el backend aplica saneo a ASCII y mayusculas.
- Soporte de camara queda como feature opcional en firmware (`#define CAMERA`).
- Si un proveedor de IA falla por cuota, el servidor intenta el siguiente en `AI_PROVIDER_ORDER`.

## Aviso

Usa este proyecto de forma etica y respetando politicas academicas y legales.

## KiCad design docs/hardware/ti84-gpt-hack-pcb/cheating-calc.kicad_pcb

File docs/hardware/README.md:

# Hardware Reference Assets

This folder stores wiring and PCB assets used by this integrated project.

## Clean Pinout Diagram

- `docs/hardware/ti84-esp32-pinout.svg`

This diagram maps TI-84 link jack pins to firmware pin usage in this repo:
- `TIP -> D1`
- `RING -> D10`
- `SLEEVE -> GND`

## Imported PCB Design (from TI-84-GPT-HACK)

Source folder used in this workspace:
- `../TI-84-GPT-HACK/pcb/`

Imported files:
- `docs/hardware/ti84-gpt-hack-pcb/schematic.png`
- `docs/hardware/ti84-gpt-hack-pcb/built.png`
- `docs/hardware/ti84-gpt-hack-pcb/outline.svg`
- `docs/hardware/ti84-gpt-hack-pcb/cheating-calc.kicad_pcb`
- `docs/hardware/ti84-gpt-hack-pcb/cheating-calc.kicad_sch`

Use these files as a reference design for:
- TI-84 link jack routing (TIP/RING/SLEEVE)
- ESP32 physical placement and board outline
- KiCad-based PCB customization for your own enclosure

## BOM Note

The imported KiCad schematic labels resistors as `R1..R4` with value `R` (placeholder).
Define actual resistor values before manufacturing a PCB.

Board: 2 copper layers, 72.0 x 22.0 mm, 8 parts (0 on the bottom side), 7 nets.

Parts:
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
Q1, Q2: MMBF170; SOT-23
R1, R2, R3, R4: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: MOUDLE-SEEEDUINO-XIAO-ESP32C3; MOUDLE14P-SMD-2.54-21X17.8MM

Connections:
+3.3V: Q1.1 (G), Q2.1 (G), R1.1, R2.1, U1.12 (3V3)
+5V: J1.4, R3.1, R4.1, U1.14 (5V)
GND: J1.3, U1.13 (GND)
RING: J1.1, Q1.3 (D), R3.2
RING_GPIO: Q1.2 (S), R1.2, U1.11 (PA6_A10_D10_MOSI)
TIP: J1.2, Q2.3 (D), R4.2
TIP_GPIO: Q2.2 (S), R2.2, U1.2 (PA4_A1_D1)

## Commit log

2026-03-06 Initial TI84-ESP32-GEMINI project with multi-AI backend and cloud deploy configs
2026-03-06 Add deployment-ready configs, multi-provider AI fallback, and GitHub publish docs
2026-03-06 Fix env loading in chat route for reliable provider order
2026-03-06 Add captive portal backend URL configuration and runtime server override
2026-03-06 Add AP backend readiness check and local/cloud PlatformIO profiles
2026-03-06 Add Raspberry Pi Zero 2 W deployment kit and AP backend verification
2026-03-06 docs: expand TI-84 hardware integration and references
2026-03-06 feat: add camera OCR fallback flow and Pi wifi tooling
